# Keil uVision project project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMComplierV506)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,LV_LVGL_H_INCLUDE_SIMPLE
  c misc: --locale=english --multibyte_chars
  c include: ..\Library\inc;..\StartUp\include;..\User;..\System\delay;..\System\sys;..\System\TIM3;..\Middleweares;..\Middleweares\LVGL\examples\porting;..\Middleweares\LVGL\src;..\Middleweares\LVGL;..\Middleweares\FreeRTOS;..\Middleweares\FreeRTOS\include;..\Middleweares\FreeRTOS\portable;..\Middleweares\FATFS;..\Middleweares\FATFS\exfuns;..\Middleweares\FATFS\source;..\Middleweares\MALLOC;..\Middleweares\TEXT;..\Hardware;..\Hardware\24C02;..\Hardware\IIC;..\Hardware\KEY;..\Hardware\LCD;..\Hardware\LED;..\Hardware\SD_CARD;..\Hardware\SPI;..\Hardware\SRAM;..\Hardware\TOUCH;..\Hardware\USART1;..\Hardware\W25Q128;..\Hardware\LIS2DH12TR;..\Hardware\SHT30;..\Hardware\BH1750;..\Hardware\SPL06;..\Hardware\ESP_AT;..\Hardware\RTC;..\Hardware\ADC;..\Hardware\WS2812;..\Hardware\BEEP;..\APP;..\APP\GUI;..\APP\GUI_Font;..\APP\GUI\generated;..\APP\GUI\custom;..\APP\app
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ../StartUp/include/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s system_stm32f4xx.c system_stm32f4xx.h
  group Library/inc
    ../Library/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group Library/src
    ../Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group APP/app
    ../APP/app/: app.c weather.c wifi.c rtos_task.c
  group APP/GUI
    ../APP/GUI/generated/: events_init.c gui_guider.c setup_scr_alarm_screen.c setup_scr_alarm_set_screen.c setup_scr_calculate_screen.c setup_scr_calendar_screen.c setup_scr_main_screen.c setup_scr_peripheral_screen.c setup_scr_setting_screen.c setup_scr_software_screen.c setup_scr_weather_screen.c setup_scr_wifi_screen.c widgets_init.c
    ../APP/GUI/: lv_mainstart.c
  group APP/GUI_Font
    ../APP/GUI_Font/: lv_Font_7.c lv_Font_8.c lv_Font_10.c lv_Font_12.c lv_Font_14.c
  group Hardware
    ../Hardware/24C02/: 24c02.c
    ../Hardware/IIC/: iic.c iic2_bus.c
    ../Hardware/KEY/: key.c
    ../Hardware/LCD/: GUI.c lcd.c
    ../Hardware/SD_CARD/: tf.c
    ../Hardware/SPI/: spi.c
    ../Hardware/SRAM/: sram.c
    ../Hardware/TOUCH/: touch.c
    ../Hardware/W25Q128/: w25q128.c
    ../Hardware/LED/: Led.c
    ../Hardware/SHT30/: sht30.c
    ../Hardware/USART1/: usart1.c
    ../Hardware/LIS2DH12TR/: lis2dh12tr.c
    ../Hardware/BH1750/: bh1750.c
    ../Hardware/SPL06/: spl06.c
    ../Hardware/ESP_AT/: esp_at.c
    ../Hardware/RTC/: rtc.c
    ../Hardware/ADC/: adc.c
    ../Hardware/WS2812/: ws2812.c
    ../Hardware/BEEP/: beep.c
  group System
    ../System/Delay/: delay.c
    ../System/Sys/: sys.c
    ../System/TIM3/: Tim3.c
  group User
    ../User/: main.c stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group FreeRTOS
    ../Middleweares/FreeRTOS/portable/: heap_4.c port.c
    ../Middleweares/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FATFS/exfuns
    ../Middleweares/FATFS/exfuns/: exfuns.c myffunicode.c
  group FATFS/source
    ../Middleweares/FATFS/source/: diskio.c ff.c ffsystem.c
  group MALLOC
    ../Middleweares/MALLOC/: malloc.c
  group FONTS
    ../Middleweares/TEXT/: fonts.c
  group LVGL/core
    ../Middleweares/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group LVGL/draw
    ../Middleweares/LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Middleweares/LVGL/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Middleweares/LVGL/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../Middleweares/LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../Middleweares/LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Middleweares/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Middleweares/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Middleweares/LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../Middleweares/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group LVGL/extra
    ../Middleweares/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../Middleweares/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../Middleweares/LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../Middleweares/LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middleweares/LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../Middleweares/LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middleweares/LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middleweares/LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middleweares/LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middleweares/LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middleweares/LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middleweares/LVGL/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Middleweares/LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middleweares/LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../Middleweares/LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ../Middleweares/LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ../Middleweares/LVGL/src/extra/others/monkey/: lv_monkey.c
    ../Middleweares/LVGL/src/extra/others/msg/: lv_msg.c
    ../Middleweares/LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../Middleweares/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../Middleweares/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../Middleweares/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../Middleweares/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../Middleweares/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middleweares/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../Middleweares/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middleweares/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middleweares/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middleweares/LVGL/src/extra/widgets/led/: lv_led.c
    ../Middleweares/LVGL/src/extra/widgets/list/: lv_list.c
    ../Middleweares/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../Middleweares/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../Middleweares/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middleweares/LVGL/src/extra/widgets/span/: lv_span.c
    ../Middleweares/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middleweares/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../Middleweares/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../Middleweares/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../Middleweares/LVGL/src/extra/widgets/win/: lv_win.c
    ../Middleweares/LVGL/src/extra/: lv_extra.c
  group LVGL/font
    ../Middleweares/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group LVGL/hal
    ../Middleweares/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL/misc
    ../Middleweares/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LVGL/widgets
    ../Middleweares/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL/porting
    ../Middleweares/LVGL/examples/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group LVGL/config
    ../Middleweares/LVGL/: lv_conf.h lvgl.h
